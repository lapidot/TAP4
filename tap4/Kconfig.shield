## tap4/Kconfig.shield
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_TAP4
    def_bool $(shields_list_contains,tap4)
```
